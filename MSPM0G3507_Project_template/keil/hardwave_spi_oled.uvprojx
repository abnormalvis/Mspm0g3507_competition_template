# Keil uVision project hardwave_spi_oled.uvprojx, settings and files
target hardwave_spi_oled (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  BeforeMake: cmd.exe /C "D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\tools\keil\syscfg.bat '$P' ncontroller.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\;..\ndrivers;.\Hal;.\App;.\Mt;.\OS;.\Hal\st2315;.\Duty;.\ZF_IMU;..\..\source;..\..\source\third_party\CMSIS\Core\Include;..\ndrivers\LCD
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group ndriver
    ../ndrivers/: drv_oled.c glcdfont.c ssd1306.c drv_spi.c
    ./Hal/: hal_key.c hal_led.c hal_beep.c hal_timer.c hal_encode.c hal_tb6612.c hal_uart.c hal_delay.c hal_motor.c hal_math.c hal_jy62.c hal_gray.c hal_vofa.c hal_pid.c hal_at24c02.c zf_common_fifo.c
    ../ndrivers/LCD/: lcd.c lcd_init.c
  group Mt
    ./Mt/: mt_test.c user_interrupt.c mt_flag.c
  group User
    ../: main.c ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group App
    ./App/: app.c seekfree_assistant.c seekfree_uart.c move_filter.c
  group Top_Duty
    ./Duty/: 2024DS_Duty.c
  group OS
    ./OS/: cpu.c OS_System.c
  group Doc
    ./: readme.txt
  group ZF_IMU
    ./ZF_IMU/: zf_device_imu_interface.c zf_device_imu660ra.c zf_common_debug.c zf_common_function.c imu_filter.c
  group source
    ../../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
